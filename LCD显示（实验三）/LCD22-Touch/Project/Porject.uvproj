# Keil uVision project Porject.uvproj, settings and files
target Open32F051C_LCD22_Touch (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Porject
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX
  c include: ..\User;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\Source;..\Libraries\CMSIS\Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: main.c stm32f0xx_it.c usart.c LCD_lib.c LTM022A69B.c User_systick.c Touch.c
  group CMSIS
    ../Libraries/CMSIS/Device/Source/: system_stm32f0xx.c
  group StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_usart.c stm32f0xx_tim.c stm32f0xx_syscfg.c stm32f0xx_spi.c stm32f0xx_rtc.c stm32f0xx_i2c.c stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_wwdg.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/Source/: startup_stm32f0xx.s
